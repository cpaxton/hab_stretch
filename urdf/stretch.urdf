Commit message: update stretch bullet setup + urdf

File: urdf/stretch.urdf (robot description, URDF)
Before this commit: robot stretch, 42 links, 41 joints
Links:
- link camera_link: geometry collision box size=0.02505 0.09 0.025; visual mesh filename=../meshes/realsense2/d435.dae
